# Keil uVision project AT32F403.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: AT32F403VG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: AT32F403Vx_XL,LIBRARY_VERSION
  c include: ..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\User\bsp\inc;..\System;..\System\delay
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ../User/: main.c
    ../Libraries/CMSIS/: at32f4xx_it.c
  group Startup
    ../Startup/: startup_at32f403vx_xl.s
  group CMSIS
    ../Libraries/CMSIS/: system_at32f4xx.c
  group FWLIB
    ../Libraries/FWLIB/src/: at32f4xx_rcc.c misc.c at32f4xx_gpio.c at32f4xx_spi.c
  group bsp
    ../User/bsp/src/: bsp_led.c bsp_spi.c bsp_lcd.c
  group System
    ../System/delay/: delay.c
